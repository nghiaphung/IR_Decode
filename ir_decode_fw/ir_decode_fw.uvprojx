# Keil uVision project ir_decode_fw.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ir_decode_fw
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F030
  c include: ..\ir_decode_fw;.\STM32F0xx_StdPeriph_Driver\inc;.\CMSIS\Include;.\CMSIS\Device\ST\STM32F0xx\Include;.\CMSIS\Device\ST\STM32F0xx\Source\Templates\arm
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Stm32F0_Lib
    ./: system_stm32f0xx.c stm32f0xx_it.c startup_stm32f030.s
    ./STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c
  group driver
    ./driver/button/: button.c
    ./driver/ir/: ir.c
    ./driver/lcd/: lcd.c
    ./driver/led/: led.c
  group user
    ./: main.c
